# Keil uVision project Demo.uvproj, settings and files
target Main (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Demo +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: STARTUP.A51
    ./Sources/: Main.c PreMacro.c HybSCH.c Led.c Button.c Bee.c
  group Headers
    ./Sources/Headers/: PreMacro.h Button.h HybSCH.h Led.h Bee.h
